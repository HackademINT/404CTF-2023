options:
  parameters:
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '100000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '100000'
    tau: '75e-8'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /run/media/rmoreau/ARCH_202303/404/404/de-la-radio-a-l-image/Challenge/H4SGEL_S1_1
    type: complex
  states: {state: disabled}
- name: blocks_freqshift_cc_0
  id: blocks_freqshift_cc
  parameters:
    freq: '40000'
    sample_rate: '100000'
  states: {}
- name: blocks_sigmf_sink_minimal_0
  id: blocks_sigmf_sink_minimal
  parameters:
    author: Racoon
    center_freq: np.nan
    description: A test file
    filename: /run/media/rmoreau/ARCH_202303/404/404/de-la-radio-a-l-image/Challenge/H4SGEL_S1_1
    sample_rate: samp_rate
    type: complex float (fc32_le)
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /run/media/rmoreau/ARCH_202303/404/404/de-la-radio-a-l-image/Conception/SSTV.wav
    repeat: 'False'
  states: {}

connections:
- [analog_wfm_tx_0, '0', blocks_freqshift_cc_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_file_sink_0, '0']
- [blocks_freqshift_cc_0, '0', blocks_sigmf_sink_minimal_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
