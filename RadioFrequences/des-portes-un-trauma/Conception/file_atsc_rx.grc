options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: file_atsc_rx
    output_language: python
    run_options: run
    title: Receive ATSC from UHD
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6/286*684
  states: {}
- name: duration
  id: variable
  parameters:
    value: '30'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 605e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '18'
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate*sps
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 4500000.0 / 286 * 684
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /run/media/rmoreau/SSD/tmp/RF/videoRX.ts
    type: byte
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /run/media/rmoreau/ARCH_202303/HackademINT_infra/404CTF_2023/ATSC/final.ts
    type: float
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /run/media/rmoreau/SSD/tmp/RF/final
    repeat: 'False'
    type: complex
  states: {}
- name: dtv_atsc_fpll_0
  id: dtv_atsc_fpll
  parameters:
    rate: sample_rate
  states: {state: disabled}
- name: dtv_atsc_rx_0
  id: dtv_atsc_rx
  parameters:
    rate: sample_rate
    sps: '1.5'
  states: {}

connections:
- [blocks_file_source_0, '0', dtv_atsc_fpll_0, '0']
- [blocks_file_source_0, '0', dtv_atsc_rx_0, '0']
- [dtv_atsc_fpll_0, '0', blocks_file_sink_1, '0']
- [dtv_atsc_rx_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
